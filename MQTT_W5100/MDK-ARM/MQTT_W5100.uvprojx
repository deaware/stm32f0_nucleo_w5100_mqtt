# Keil uVision project MQTT_W5100.uvprojx, settings and files
target MQTT_W5100 Configuration (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: MQTT_W5100 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,DEBUG,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Wiznet;..\mqtt;..\Drivers\BSP\Components\Common;..\Drivers\BSP\Components\hts221;..\Drivers\BSP\Components\lis3mdl;..\Drivers\BSP\Components\lps25h;..\Drivers\BSP\Components\lps25hb;..\Drivers\BSP\Components\lsm6ds0;..\Drivers\BSP\Components\lsm6ds3;..\Drivers\BSP\X_NUCLEO_IKS01A1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc.c stm32f0xx_hal.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_pwr.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c app.c
    ../Wiznet/: socket.c wizchip_conf.c
    ../Wiznet/W5100/: w5100.c
    ../src/: debug.c app_sensor.c
    ../mqtt/: mqtt-msg.c
  group BSP
    ../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c
    ../Drivers/BSP/Components/hts221/: hts221.c
    ../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../Drivers/BSP/Components/lps25h/: lps25h.c
    ../Drivers/BSP/Components/lps25hb/: lps25hb.c
    ../Drivers/BSP/Components/lsm6ds0/: lsm6ds0.c
    ../Drivers/BSP/Components/lsm6ds3/: lsm6ds3.c
